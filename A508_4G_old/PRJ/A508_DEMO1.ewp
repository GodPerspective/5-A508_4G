# IAR project A508_DEMO1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S007C8 STM8S007C8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x00
  ICCSTM8.CCDefines: STM8S007
  ICCSTM8.CCIncludePath2: ..\INCLUDE; ..\MAIN; ..\SRC\MCU\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: A508_DEMO1.hex
  ILINK.IlinkOutputFile: A508_DEMO1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group INCLUDE
    ../INCLUDE/: ADC.h AllHead.h ApiAtCmd.h ApiBeidou.h ApiDisplay.h ApiGpsCmd.h ApiKeyboard.h ApiLED.h ApiMenu.h ApiPocCmd.h Beep.h CommonLib.h Config.h DataStructAddr.h Define.h Delay.h DrvFont.h DrvGD83.h DrvGT20L16S1Y.h DrvHTG12832.h DrvI2cAw87319.h DrvKeyboard.h Flash_eeprom.h GT20L16P1Y.h GT20L16P1Y_D.h KeyCmd.h McuConfig.h sysclock.h System.h Task.h Tone.h uart3.h Voice.h
  group MAIN
    ../MAIN/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group SRC/Drv
    ../SRC/Drv/: ADC.c DrvGD83.c DrvGT20L16S1Y.c DrvHTG12832.c DrvI2cAw87319.c DrvKeyboard.c Voice.c
  group SRC/MCU
    ../SRC/MCU/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group SRC/Support
    ../SRC/Support/: CommonLib.c Config.c McuConfig.c sysclock.c System.c
  group SRC/System
    ../SRC/Syetem/: ApiAtCmd.c ApiBeidou.c ApiDisplay.c ApiGpsCmd.c ApiKeyboard.c ApiLED.c ApiMenu.c ApiPocCmd.c Beep.c Delay.c Flash_eeprom.c GT20L16_STM8_DOUBLE_MEDIUM_IAR.a GT20L16P1Y_D.c KeyCmd.c Task.c Tone.c uart3.c
